# IAR project LightController.ewp, settings and files
configuration CC2530-End Device (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: MCU_H=<ioCC2530.h>; MRFI_CC2530
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: Components\bsp; Components\bsp\drivers; Components\bsp\boards\CC2530EM; Components\mrfi; Components\Simpliciti\nwk; Components\Simpliciti\nwk_applications; src
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration CC2530-Access Point (8051, debug)
  as the first configuration, except:
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration CC2530-Channel Sniffer (8051, debug)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F32.i51
  ICC8051.CCDefines: MCU_H=<ioCC2530.h>; MRFI_CC2530; NUM_CONNECTIONS=0
  ICC8051.CCIncludePath2: ..\..\..\..\..\Components\bsp; ..\..\..\..\..\Components\bsp\drivers; ..\..\..\..\..\Components\bsp\boards\CC2530EM; ..\..\..\..\..\Components\mrfi; ..\..\..\..\..\Components\SimpliciTI\nwk; ..\..\..\..\..\Components\SimpliciTI\nwk_applications
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F32.xcl
configuration CC2530-Range Extender (8051, debug)
  as the first configuration, except:
  ICC8051.CCIncludePath2: as above
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530.xcl
  group Components/bsp
    Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/dimmer
    src/: dimmer.c dimmer.h
  group Components/flash
    src/: nv.c nv.h
  group Components/mrfi
    Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    Components/Simpliciti/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_security.c nwk_security.h
    Components/Simpliciti/nwk_applications/: nwk_pll.h
  group Components/radio
    src/: radio.c radio.h
  group Components/rfm12
    src/: rfm12.c rfm12.h
  group Components/spi
    src/: spi.c spi.h
  group Components/timer
    src/: timer.c timer.h
  group Components/uart
    Components/bsp/drivers/code/: uart.c uart_intfc.c
    Components/bsp/drivers/: uart.h uart_intfc.h
  group Components/utils
    src/: atcommands.h utils.c utils.h
  group peer applications/application/Access Point
    src/: AP.c
  group peer applications/application/Channel Sniffer
    ../../../Applications/: main_ED_Sniffer.c
  group peer applications/application/End Device
    src/: ED.c
  group peer applications/application/Range Extender
    ../../../Applications/: main_AP_RE.c
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
    Configuration/: smpl_nwk_config.dat
